Commit message: 保存sim2sim验证进展并新增M24螺母任务

File: assets/screw/trinut/0003_stripe.urdf (robot description, URDF)
Before this commit: robot screw_with_nut, 3 links, 2 joints
Links:
- link nut: geometry collision mesh filename=../../meshes/tri.stl scale=1.0 1.0 6.5; visual box size=0.002 0.05 0.03
